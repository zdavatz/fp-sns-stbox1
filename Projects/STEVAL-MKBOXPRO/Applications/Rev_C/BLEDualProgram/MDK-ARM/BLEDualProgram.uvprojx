# Keil uVision project BLEDualProgram.uvprojx, settings and files
target BLEDualProgram (6190000::V6.19::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.4
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: BLEDualProgram +hex
  AfterMake: fromelf #L --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U585xx
  c misc: -Wno-format
  c include: ../Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/Third_Party/parson;../../../../../../Middlewares/ST/STM32_BLE_Manager/Inc;../../../../../../Middlewares/ST/STM32WB07_06/utils;../../../../../../Middlewares/ST/STM32WB07_06/includes;../../../../../../Middlewares/ST/STM32WB07_06/hci/hci_tl_patterns/Basic;../../../../../../Drivers/BSP/SensorTileBoxPro;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/stc3115;../../../../../../Drivers/BSP/Components/st25dvxxkc;../../../../../../Drivers/BSP/Components/lis2mdl;../../../../../../Drivers/BSP/Components/lps22df;../../../../../../Drivers/BSP/Components/lis2du12;../../../../../../Drivers/BSP/Components/stts22h;../../../../../../Drivers/BSP/Components/lsm6dsv16x;../../../../../../Drivers/BSP/Components/ST25DV;../../../../../../Middlewares/ST/lib_nfc/lib_NDEF/Core/inc;../../../../../../Middlewares/ST/lib_nfc/Common/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: main.c ble_function.c ota.c lib_NDEF_config.c app_bledualprogram.c ble_implementation.c hci_tl_interface.c steval_mkboxpro_bus.c steval_mkboxpro.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Drivers/BSP/SensorTileBoxPro
    ../../../../../../Drivers/BSP/SensorTileBoxPro/: SensorTileBoxPro_audio.c SensorTileBoxPro_env_sensors.c SensorTileBoxPro_env_sensors_ex.c SensorTileBoxPro_gg.c SensorTileBoxPro_motion_sensors.c SensorTileBoxPro_motion_sensors_ex.c SensorTileBoxPro_nfctag.c SensorTileBoxPro_nfctag_ex.c SensorTileBoxPro_sd.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stc3115/: STC3115_Driver.c
    ../../../../../../Drivers/BSP/Components/st25dvxxkc/: st25dvxxkc_reg.c st25dvxxkc.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl_reg.c lis2mdl.c
    ../../../../../../Drivers/BSP/Components/lps22df/: lps22df_reg.c lps22df.c
    ../../../../../../Drivers/BSP/Components/lis2du12/: lis2du12_reg.c lis2du12.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h_reg.c stts22h.c
    ../../../../../../Drivers/BSP/Components/lsm6dsv16x/: lsm6dsv16x_reg.c lsm6dsv16x.c
    ../../../../../../Drivers/BSP/Components/ST25DV/: st25dv_reg.c st25dv.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_mdf.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_sdio.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Middlewares/parson/Data Exchange/parson
    ../../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Environmental
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_environmental.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Inertial
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_inertial.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/SensorFusion
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_sensor_fusion.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/BLE_Manager
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_manager.c
  group Middlewares/STM32WB07_06/Wireless/STM32WB07_06/Utils
    ../../../../../../Middlewares/ST/STM32WB07_06/utils/: ble_list.c
  group Middlewares/STM32WB07_06/Wireless/STM32WB07_06/Controller
    ../../../../../../Middlewares/ST/STM32WB07_06/hci/controller/: stm32wb07_06_gap_aci.c stm32wb07_06_gatt_aci.c stm32wb07_06_hal_aci.c stm32wb07_06_l2cap_aci.c
  group Middlewares/STM32WB07_06/Wireless/STM32WB07_06/HCI_TL/Basic
    ../../../../../../Middlewares/ST/STM32WB07_06/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../../Middlewares/ST/STM32WB07_06/hci/: stm32wb07_06_dev_config.c stm32wb07_06_events.c stm32wb07_06_events_cb.c stm32wb07_06_hci_le.c
  group Middlewares/STEVAL-MKBOXPRO/Documentation
    ../../../../../../Drivers/BSP/SensorTileBoxPro/: LICENSE.txt
    ../../../../../../Drivers/BSP/Components/Common/: LICENSE.txt
  group Middlewares/lib_nfc/Wireless/lib_nfc/Core
    ../../../../../../Middlewares/ST/lib_nfc/lib_NDEF/Core/src/: lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Bluetooth.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_Handover.c lib_NDEF_MyApp.c lib_NDEF_SMS.c lib_NDEF_Text.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_NDEF_Wifi.c lib_wrapper.c tagtype3_wrapper.c tagtype4_wrapper.c tagtype5_wrapper.c
software components: CMSIS:CORE 4.3.0
