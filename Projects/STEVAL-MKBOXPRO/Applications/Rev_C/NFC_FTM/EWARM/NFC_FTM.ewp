# IAR project NFC_FTM.ewp, settings and files
configuration NFC_FTM (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U585xx
  ICCARM.CCDiagSuppress: Pa089
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/SensorTileBoxPro; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/stc3115; ../../../../../../Middlewares/ST/ST25FTM/Inc; ../../../../../../Drivers/BSP/Components/st25dvxxkc; ../../../../../../Drivers/BSP/Components/lis2mdl; ../../../../../../Drivers/BSP/Components/lps22df; ../../../../../../Drivers/BSP/Components/lis2du12; ../../../../../../Drivers/BSP/Components/stts22h; ../../../../../../Drivers/BSP/Components/lsm6dsv16x; ../../../../../../Drivers/BSP/Components/ST25DV
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NFC_FTM.bin
  ILINK.IlinkOutputFile: NFC_FTM.out
  ILINK.IlinkIcfFile: stm32u585xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: main.c flashl4_if.c ftm_process.c fw_command.c logger.c st25ftm_config.c app_nfc_ftm.c steval_mkboxpro_bus.c steval_mkboxpro.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stc3115/: STC3115_Driver.c
    ../../../../../../Drivers/BSP/Components/st25dvxxkc/: st25dvxxkc_reg.c st25dvxxkc.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl_reg.c lis2mdl.c
    ../../../../../../Drivers/BSP/Components/lps22df/: lps22df_reg.c lps22df.c
    ../../../../../../Drivers/BSP/Components/lis2du12/: lis2du12_reg.c lis2du12.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h_reg.c stts22h.c
    ../../../../../../Drivers/BSP/Components/lsm6dsv16x/: lsm6dsv16x_reg.c lsm6dsv16x.c
    ../../../../../../Drivers/BSP/Components/ST25DV/: st25dv_reg.c st25dv.c
  group Drivers/BSP/SensorTileBoxPro
    ../../../../../../Drivers/BSP/SensorTileBoxPro/: SensorTileBoxPro_audio.c SensorTileBoxPro_env_sensors.c SensorTileBoxPro_env_sensors_ex.c SensorTileBoxPro_gg.c SensorTileBoxPro_motion_sensors.c SensorTileBoxPro_motion_sensors_ex.c SensorTileBoxPro_nfctag.c SensorTileBoxPro_nfctag_ex.c SensorTileBoxPro_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_mdf.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_sdio.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_ll_usb.c
  group Middlewares/ST25FTM/Middlewares/ST25FTM
    ../../../../../../Middlewares/ST/ST25FTM/Src/: st25ftm_common.c st25ftm_protocol.c st25ftm_rx.c st25ftm_tx.c
  group Middlewares/STEVAL-MKBOXPRO/Documentation
    ../../../../../../Drivers/BSP/SensorTileBoxPro/: LICENSE.txt
    ../../../../../../Drivers/BSP/Components/Common/: LICENSE.txt
