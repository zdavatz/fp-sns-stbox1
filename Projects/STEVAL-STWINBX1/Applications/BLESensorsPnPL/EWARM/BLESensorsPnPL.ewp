# IAR project BLESensorsPnPL.ewp, settings and files
configuration BLESensorsPnPL (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U585xx
  ICCARM.CCDiagSuppress: Pa205
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/ST/STM32_BLE_Manager/Inc; ../../../../../Middlewares/Third_Party/parson; ../../../../../Drivers/BSP/STWIN.box; ../../../../../Drivers/BSP/Components/Common; ../../../../../Middlewares/ST/PnPLCompManager/Inc; ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic; ../../../../../Middlewares/ST/BlueNRG-2/utils; ../../../../../Middlewares/ST/BlueNRG-2/includes; ../../../../../Drivers/BSP/Components/ism330dhcx; ../../../../../Drivers/BSP/Components/iis2mdc; ../../../../../Drivers/BSP/Components/iis2dlpc; ../../../../../Drivers/BSP/Components/iis2iclx; ../../../../../Drivers/BSP/Components/iis3dwb; ../../../../../Drivers/BSP/Components/stts22h; ../../../../../Drivers/BSP/Components/ilps22qs; ../../../../../Drivers/BSP/Components/ST25DV
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLESensorsPnPL.bin
  ILINK.IlinkOutputFile: BLESensorsPnPL.out
  ILINK.IlinkIcfFile: stm32u585xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: main.c ota.c ble_function.c configuration_pn_p_l.c control_pn_p_l.c device_information_pn_p_l.c environmental_pn_p_l.c inertial_pn_p_l.c app_model.c i_control.c app_blesensorspnpl.c hci_tl_interface.c ble_implementation.c steval_stwinbx1_bus.c steval_stwinbx1.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx_reg.c ism330dhcx.c
    ../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc_reg.c iis2mdc.c
    ../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc_reg.c iis2dlpc.c
    ../../../../../Drivers/BSP/Components/iis2iclx/: iis2iclx_reg.c iis2iclx.c
    ../../../../../Drivers/BSP/Components/iis3dwb/: iis3dwb_reg.c iis3dwb.c
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h_reg.c stts22h.c
    ../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs_reg.c ilps22qs.c
    ../../../../../Drivers/BSP/Components/ST25DV/: st25dv_reg.c st25dv.c
  group Drivers/BSP/STWIN.box
    ../../../../../Drivers/BSP/STWIN.box/: STWIN.box_audio.c STWIN.box_bc.c STWIN.box_debug_pins.c STWIN.box_env_sensors.c STWIN.box_env_sensors_ex.c STWIN.box_motion_sensors.c STWIN.box_motion_sensors_ex.c STWIN.box_nfctag.c STWIN.box_sd.c
  group Drivers/BSP/STWINbox
    ../../../../../Drivers/BSP/STWIN.box/: STWIN.box_audio.c STWIN.box_bc.c STWIN.box_debug_pins.c STWIN.box_env_sensors.c STWIN.box_env_sensors_ex.c STWIN.box_motion_sensors.c STWIN.box_motion_sensors_ex.c STWIN.box_nfctag.c STWIN.box_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_mdf.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dac.c stm32u5xx_hal_dac_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_sdio.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_ll_usb.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Controller
    ../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_devConfig.c bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Utils
    ../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/parson/Data Exchange/parson
    ../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/PnPLCompManager/Middlewares/PnPLCompManager
    ../../../../../Middlewares/ST/PnPLCompManager/Src/: IPnPLComponent.c PnPLCompManager.c
  group Middlewares/STEVAL-STWINBX1/Documentation
    ../../../../../Drivers/BSP/Components/Common/: LICENSE.txt
  group Middlewares/STM32_BLE_Manager/BLE_Features/BLE_Manager
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_manager.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Battery
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_battery.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Environmental
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_environmental.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Inertial
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_inertial.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/PnP/PnPLike
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_pn_p_like.c
