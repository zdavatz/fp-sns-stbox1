# Keil uVision project NFC_FTM.uvprojx, settings and files
target NFC_FTM (6190000::V6.19::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.4
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: NFC_FTM +hex
  AfterMake: fromelf #L --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U585xx
  c misc: -Wno-format -Wno-enum-conversion
  c include: ../Inc;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/STWIN.box;../../../../../Drivers/BSP/Components/Common;../../../../../Middlewares/ST/ST25FTM/Inc;../../../../../Drivers/BSP/Components/ism330dhcx;../../../../../Drivers/BSP/Components/iis2mdc;../../../../../Drivers/BSP/Components/iis2dlpc;../../../../../Drivers/BSP/Components/iis2iclx;../../../../../Drivers/BSP/Components/iis3dwb;../../../../../Drivers/BSP/Components/stts22h;../../../../../Drivers/BSP/Components/ilps22qs;../../../../../Drivers/BSP/Components/ST25DV
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: main.c flashl4_if.c ftm_process.c fw_command.c logger.c st25ftm_config.c app_nfc_ftm.c steval_stwinbx1_bus.c steval_stwinbx1.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Drivers/BSP/STWIN.box
    ../../../../../Drivers/BSP/STWIN.box/: STWIN.box_audio.c STWIN.box_bc.c STWIN.box_debug_pins.c STWIN.box_env_sensors.c STWIN.box_env_sensors_ex.c STWIN.box_motion_sensors.c STWIN.box_motion_sensors_ex.c STWIN.box_nfctag.c STWIN.box_sd.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx_reg.c ism330dhcx.c
    ../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc_reg.c iis2mdc.c
    ../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc_reg.c iis2dlpc.c
    ../../../../../Drivers/BSP/Components/iis2iclx/: iis2iclx_reg.c iis2iclx.c
    ../../../../../Drivers/BSP/Components/iis3dwb/: iis3dwb_reg.c iis3dwb.c
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h_reg.c stts22h.c
    ../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs_reg.c ilps22qs.c
    ../../../../../Drivers/BSP/Components/ST25DV/: st25dv_reg.c st25dv.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_mdf.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dac.c stm32u5xx_hal_dac_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_sdio.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Middlewares/STEVAL-STWINBX1/Documentation
    ../../../../../Drivers/BSP/Components/Common/: LICENSE.txt
  group Middlewares/ST25FTM/Middlewares/ST25FTM
    ../../../../../Middlewares/ST/ST25FTM/Src/: st25ftm_common.c st25ftm_protocol.c st25ftm_rx.c st25ftm_tx.c
software components: CMSIS:CORE 4.3.0
